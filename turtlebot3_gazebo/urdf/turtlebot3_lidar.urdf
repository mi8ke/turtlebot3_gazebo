Commit message: dummy_link削除

File: turtlebot3_gazebo/urdf/turtlebot3_lidar.urdf (robot description, URDF)
Before this commit: robot my_robot, 3 links, 2 joints
Links:
- removed link dummy_link
Joints:
- removed joint dummy_joint
